Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-08-17T13:53:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 17 13:53:36 2021* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{11C66634-500E-4B66-91F8-2BDD049F0629}\ifc* Database version: 5507* Database creation date: Tue Aug 17 13:53:16 2021* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 17 13:53:33 2021* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 17 13:53:33 2021* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcTransportElement: EasyMove_E07_1250x1000mm, NBS_VimecSRL_VrtclLftngPltfrms_EasyMove_E07:EasyMove_E07_1250x1000mm:318299
In: Level 0
Type - PredefinedType: ELEVATOR; Classification: Pr_65_80_47_95 (Uniclass2015); Material: NBS_VimecAccessibilityLtd_Vimec7040, NBS_VimecAccessibilityLtd_Similinox, NBS_Glass_Single
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VimecSRL_PlatformLifts_EasyMove_E07_1250x1000mm; ManufacturerName: Vimec SRL; ManufacturerURL: www.vimec.biz; NBSCertification: www.nationalbimlibrary.com/cert/x3z4sb1s; NBSDescription: Platform lifts; NBSReference: 90-80-65/350; ProductInformation: n/a; Revision: n/a; Uniclass2015Title: Vertical lifting platforms; Uniclass2015Code: Pr_65_80_47_95; Uniclass2015Version: Products v1.20; Version: 1
Type - NBS_Data - Standard: UNI EN 81-41; RatedLoadMinimum: Up to 400 kg; DriveType: Automatic; ControlDeviceType: Button panel with LCD display; ControlFeatures: LCD display, loudspeaker, load indicator, alarm pushbutton, I-button for electronic access floor controls, green and red free and busy floor indicators; ElectricalSupply: Single Phase 230V 50Hz; Accessories: Phone handset, Autodialler, GSM Autodialler, Remote Landing pushes, I-Button, Floor Announcement, Horizontal Cabin Mirror, Vertical Cabin Mirror, LCD display on landing pushes, Stainless Steel Landing Pushes, Kit for flooring by others, Shaft lighting; CarriageType: n/a; CarrierFrameMaterial: Various; CarrierFrameFinish: Vimec 7040; CarrierFrameColour: Vimec 7040; CarrierInfillMaterial: Steel or Glass; CarrierInfillFinish: Coated Steel Colour Type, Stainless Steel, Glass; CarrierInsertColour: Coated Steel Colur Type: Grey similinox, Blue, Beige, Cherry, Maple, Matt White, brushed stainless steel, polished linen stainless steel, special RAL colour; DoorsArrangement: Telescopic (automatic) or Hinged (constant pressure); DoorsType: Hinged orTelescopic; DoorsClearOpeningWidthMinimum: Panel Door 600,650,700,750,800,860 Aluminium Panoramic Door 600,650,700,750,800,860 Double Hinged Door 700,750,800 Automatic telescopic 2 panel door 700,Automatic telescopic 3 panel door 600, 650, 700,750,800; DoorsFireRatingMinimum: 120 Mins (telescopic), 60 or 120 (Hinged); DoorsFrameMaterial: Automatic telescopic: 2 panel, 3 panel, 4 panel, Panel Door (single hinged), Panoramic Door (single hinged) Aluminium panoramic door (single hinged), Double hinged door; DoorsFrameFinish: Grey Similinox (Telescopic) 441 Stainless Steel (telescopic) 316 Stainless Steel (telescopic) Vimec 7040, Special RAL; DoorsFrameColour: Vimec 7040; DoorsInfillMaterial: Coated Steel Colour Type, Stainless Steel, Painted Steel; DoorsInfillFinish: Grey Similinox (Telescopic) 441 Stainless Steel (telescopic) 316 Stainless Steel (telescopic) Vimec 7040, Special RAL; DoorsInfillColour: Grey Similinox, Polished linen or brushed Stainless Steel, Special RAL; CarrierFloorDimensionsWidthMinimum: 970mm; CarrierFloorDimensionsDepthMinimum: 1220mm; CarrierFloorMaterial: Non slip PVC / Rubber; CarrierFloorColour: PVC Rubber Grey floor with stamps PVC Red, dark grey, light grey, wild pear; Applications: Any environment, whether a home or a public building, both for indoor and outdoor; Speed: 0,15 m/sec; Motor: 1.8 kW; AuxiliaryCircuit: 24V-dc; SafetySystems: Down speed control valve integrated in the cylinder, safety gear, pressure relief valve on the hydraulic circuit, emergency descent from floor, level, hand pump and pressure switch, full height infrared barrier on each access; LiftingSystem: Hydraulic; LiftingTravel: 9500 mm; AutomaticSafetyLevelling: +/- 20 mm
Type - Pset_TransportElementCommon - CapacityPeople: 5; CapacityWeight: 400; FireExit: no; Reference: n/a
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no; IK_Code: n/a; IP_Code: n/a; NominalFrequencyRange: n/a; NumberOfPoles: 0; PowerFactor: 0; RatedCurrent: n/a; RatedVoltage: 230 V
Type - IFC - IfcExportAs: IfcTransportElementType; IfcExportType: ELEVATOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_65_80_47_95:Vertical lifting platforms; CodePerformance: UNI EN 81-2; Color: Vimec 7040, Special RAL; Constituents: n/a; Description: Versatile hydraulic lift, Lifting system for a person with limited locomotory capacity; DurationUnit: year; ExpectedLife: 15 years; Features: User customisable, easy to install in existing shafts; Finish: Coated with stainless steel; Grade: n/a; Manufacturer: info@vimec.biz; Material: Aluminium, steel, glass opt; ModelNumber: E07; ModelReference: EasyMove_E07; Name: PlatformLifts_EasyMove_E07_1250x1000mm_VimecSRL; NominalHeight: 2000 mm; NominalLength: 1000 mm; NominalWidth: 1250 mm; ReplacementCost: n/a; Shape: n/a; Size: 2000 x 1250 x 1000 mm; SustainabilityPerformance: n/a; WarrantyDescription: 2 Years warranty on parts; WarrantyDurationLabor: n/a; WarrantyDurationParts: Included; WarrantyDurationUnit: 2 years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
